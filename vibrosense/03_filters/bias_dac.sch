v {xschem version=3.4.0 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {VibroSense Block 03 — 4-bit Bias Current DAC
Binary-weighted current mirror (1x/2x/4x/8x)
See bias_dac.spice for netlist
See ota_bias_dist.spice for OTA-matched bias distribution} 50 50 0 0 0.4 0.4 {}
