v {xschem version=3.4.0 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {VibroSense Block 03 — Channel 5 BPF
Tow-Thomas biquad using 3x ota_foldcasc (Block 01)
See bpf_ch5_real.spice for transistor-level netlist
Schematic pending Xschem GUI layout} 50 50 0 0 0.4 0.4 {}
